*Heading
** Job name: Implicit Model name: Model-2
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=PART-2-1
*End Part
**
*Part, name=PART-3-1
*Node
      1,  0.451303899,  0.418020308, 0.0500000007
      2,  0.449815094,    0.4197478, 0.0500000007
      3,  0.449068397,  0.419112712, 0.0500000007
      4,   0.45054999,  0.417370588, 0.0500000007
      5,  0.449815094,    0.4197478, 0.0460000001
      6,  0.451303899,  0.418020308, 0.0460000001
      7,  0.448656112,  0.415738493, 0.0474999994
      8,  0.448656112,  0.415738493, 0.0460000001
      9,   0.44716391,  0.417493105, 0.0460000001
     10,   0.44716391,  0.417493105, 0.0474999994
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*Element, type=C3D8R
   1, 1204, 1205, 2855, 2832,  225,  226, 1178, 1177
   2, 1205,  234, 1189, 2855,  226,    1,  227, 1178
   3, 2832, 2855, 2835, 2826, 1177, 1178, 1180, 1179
   4, 2855, 1189, 1190, 2835, 1178,  227,  228, 1180
   5, 1206, 1207, 2856, 2833, 1204, 1205, 2855, 2832
   6, 1207,  233, 1191, 2856, 1205,  234, 1189, 2855
   7, 2833, 2856, 2836, 2825, 2832, 2855, 2835, 2826
   8, 2856, 1191, 1192, 2836, 2855, 1189, 1190, 2835
   9, 1208, 1209, 2857, 2834, 1206, 1207, 2856, 2833
  10, 1209,  232, 1193, 2857, 1207,  233, 1191, 2856
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*Elset, elset=_PICKEDSET3, internal, generate
    1,  3795,     1
** Section: Section-1-_PICKEDSET3
*Solid Section, elset=_PICKEDSET3, controls=EC-1, material="WEAK MATERIAL"
1.,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=PART-2-1-1, part=PART-2-1
   -0.429023,    -0.018684,           0.
*Node
      1,  0.449999988, 0.0500000007,           0.
*Nset, nset=PART-2-1-1-RefPt_, internal
 1,
*Nset, nset=PART-2-1-REFPT_, internal
 1,
*Surface, type=CYLINDER, name=m_Surf-1
START,         0.45,           0.
 LINE,         0.45,         0.05
*Rigid Body, ref node=PART-2-1-1-RefPt_, analytical surface=m_Surf-1
*End Instance
**
*Instance, name=PART-3-1-1, part=PART-3-1
   -0.432962,    -0.405846,      -0.0276
*End Instance
**
*End Assembly
**
** ELEMENT CONTROLS
**
*Section Controls, name=EC-1, hourglass=ENHANCED
1., 1., 1.
**
** MATERIALS
**
*Material, name="WEAK MATERIAL"
*Density
1100.,
*Elastic
 6.07e+07, 0.4
