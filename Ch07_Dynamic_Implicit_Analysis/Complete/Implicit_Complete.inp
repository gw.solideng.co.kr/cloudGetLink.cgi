*Heading
** Job name: Implicit Model name: Model-2
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=PART-2-1
*End Part
**
*Part, name=PART-3-1
*Node
      1,  0.451303899,  0.418020308, 0.0500000007
      2,  0.449815094,    0.4197478, 0.0500000007
      3,  0.449068397,  0.419112712, 0.0500000007
      4,   0.45054999,  0.417370588, 0.0500000007
      5,  0.449815094,    0.4197478, 0.0460000001
      6,  0.451303899,  0.418020308, 0.0460000001
      7,  0.448656112,  0.415738493, 0.0474999994
      8,  0.448656112,  0.415738493, 0.0460000001
      9,   0.44716391,  0.417493105, 0.0460000001
     10,   0.44716391,  0.417493105, 0.0474999994
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*Element, type=C3D8R
   1, 1204, 1205, 2855, 2832,  225,  226, 1178, 1177
   2, 1205,  234, 1189, 2855,  226,    1,  227, 1178
   3, 2832, 2855, 2835, 2826, 1177, 1178, 1180, 1179
   4, 2855, 1189, 1190, 2835, 1178,  227,  228, 1180
   5, 1206, 1207, 2856, 2833, 1204, 1205, 2855, 2832
   6, 1207,  233, 1191, 2856, 1205,  234, 1189, 2855
   7, 2833, 2856, 2836, 2825, 2832, 2855, 2835, 2826
   8, 2856, 1191, 1192, 2836, 2855, 1189, 1190, 2835
   9, 1208, 1209, 2857, 2834, 1206, 1207, 2856, 2833
  10, 1209,  232, 1193, 2857, 1207,  233, 1191, 2856
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*Elset, elset=_PICKEDSET3, internal, generate
    1,  3795,     1
** Section: Section-1-_PICKEDSET3
*Solid Section, elset=_PICKEDSET3, controls=EC-1, material="WEAK MATERIAL"
1.,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=PART-2-1-1, part=PART-2-1
   -0.429023,    -0.018684,           0.
*Node
      1,  0.449999988, 0.0500000007,           0.
*Nset, nset=PART-2-1-1-RefPt_, internal
 1,
*Nset, nset=PART-2-1-REFPT_, internal
 1,
*Surface, type=CYLINDER, name=m_Surf-1
START,         0.45,           0.
 LINE,         0.45,         0.05
*Rigid Body, ref node=PART-2-1-1-RefPt_, analytical surface=m_Surf-1
*End Instance
**
*Instance, name=PART-3-1-1, part=PART-3-1
   -0.432962,    -0.405846,      -0.0276
*End Instance
**
*Nset, nset=_PickedSet18, internal, instance=PART-3-1-1
   23,   36,   38,   39,   56,   58,   59,   92,  222,  337,  338,  339,  340,  341,  342,  392
  393,  394,  395,  396,  397,  398,  399,  409,  410,  411,  412,  413,  414,  439,  440,  441
  442,  443,  444,  445,  446,  447,  448,  609,  610,  611,  612,  613,  620,  621,  622,  623
  624,  625, 1099, 1100, 1101, 1102, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 1453
 1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 1463, 1464, 1465, 1466, 1467, 1795, 1796
 1797, 1798, 1799, 1800, 1801, 1802, 1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812
 1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 1823, 1824
*Nset, nset=_PickedSet19, internal, instance=PART-3-1-1
    1,    2,    3,    4,   14,   15,   16,   17,   20,   21,   22,   37,   38,   39,   40,   41
   42,   43,   44,   45,   46,   47,   48,   49,   50,   57,   58,   59,   60,   61,   62,   63
   64,   67,   68,   69,   70,   77,   78,   79,   80,   81,   82,   83,   84,   85,   86,   87
   88,   89,   90,   91,   92,  132,  133,  134,  135,  136,  137,  138,  139,  140,  141,  142
  143,  144,  145,  146,  147,  148,  149,  150,  151,  152,  153,  154,  155,  156,  157,  158
  159,  160,  161,  162,  163,  164,  165,  166,  167,  168,  169,  170,  171,  172,  173,  174
  175,  176,  177,  178,  179,  180,  181,  182,  183,  184,  185,  186,  187,  188,  189,  190
  191,  192,  193,  194,  195,  196,  197,  198,  199,  200,  201,  202,  203,  204,  205,  206
  207,  208,  209,  210,  211,  212,  213,  214,  215,  216,  217,  218,  219,  220,  221,  222
  223,  224,  225,  226,  227,  228,  229,  235,  236,  237,  238,  244,  245,  246,  294,  295
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*Nset, nset=_PickedSet20, internal, instance=PART-2-1-1
 1,
*Nset, nset=_PickedSet21, internal, instance=PART-2-1-1
 1,
*Elset, elset=__PickedSurf16_S2, internal, instance=PART-3-1-1
 183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 207, 208, 209, 213
 214,
*Elset, elset=__PickedSurf16_S3, internal, instance=PART-3-1-1
   33,   34,   35,   39,   40,   41,   45,   46,   47,   51,   52,   53,  107,  108,  151,  152
  155,  156,  253,  254,  259,  287,  288,  293,  321,  322,  327,  355,  356,  361,  389,  390
  395,  432,  444,  456,  468,  480,  492,  615,  616,  626,  627,  628,  629,  678,  679,  689
  690,  691,  692,  741,  742,  752,  753,  754,  755,  804,  805,  815,  816,  817,  818,  867
  868,  878,  879,  880,  881,  930,  931,  941,  942,  943,  944, 1214, 1215, 1216, 1217, 1218
 1219, 1395, 1396, 1397, 1398, 1399, 1400, 1576, 1577, 1578, 1579, 1580, 1581, 1757, 1758, 1759
 1760, 1761, 1762, 1938, 1939, 1940, 1941, 1942, 1943, 2119, 2120, 2121, 2122, 2123, 2124, 2300
 2358, 2362, 2385, 2393, 2434, 2603, 2661, 2665, 2688, 2696, 2737, 2906, 2964, 2968, 2991, 2999
 3040, 3209, 3267, 3271, 3294, 3302, 3343, 3512, 3570, 3574, 3597, 3605, 3646
*Elset, elset=__PickedSurf16_S4, internal, instance=PART-3-1-1
   18,   20,   22,   24,   26,   28,   30,   32,   82,   84,   86,   88,  112,  114,  116,  136
  138,  140,  142,  144,  146,  148,  150,  252,  258,  268,  272,  276,  286,  292,  302,  306
  310,  320,  326,  336,  340,  344,  354,  360,  370,  374,  378,  388,  394,  404,  408,  412
  429,  432,  441,  444,  453,  456,  465,  468,  477,  480,  489,  492,  496,  511,  516,  531
  536,  551,  556,  571,  576,  591,  596,  611,  672,  735,  798,  861,  924,  987,  992,  998
 1008, 1012, 1016, 1026, 1032, 1042, 1046, 1050, 1060, 1066, 1076, 1080, 1084, 1094, 1100, 1110
 1114, 1118, 1128, 1134, 1144, 1148, 1152, 1162, 1168, 1178, 1182, 1186, 1196, 1207, 1213, 1219
 1231, 1234, 1237, 1377, 1388, 1394, 1400, 1412, 1415, 1418, 1558, 1569, 1575, 1581, 1593, 1596
 1599, 1739, 1750, 1756, 1762, 1774, 1777, 1780, 1920, 1931, 1937, 1943, 1955, 1958, 1961, 2101
 2112, 2118, 2124, 2136, 2139, 2142, 2284, 2299, 2304, 2308, 2312, 2384, 2392, 2403, 2409, 2415
 2427, 2430, 2433, 2580, 2583, 2587, 2602, 2607, 2611, 2615, 2687, 2695, 2706, 2712, 2718, 2730
 2733, 2736, 2883, 2886, 2890, 2905, 2910, 2914, 2918, 2990, 2998, 3009, 3015, 3021, 3033, 3036
 3039, 3186, 3189, 3193, 3208, 3213, 3217, 3221, 3293, 3301, 3312, 3318, 3324, 3336, 3339, 3342
 3489, 3492, 3496, 3511, 3516, 3520, 3524, 3596, 3604, 3615, 3621, 3627, 3639, 3642, 3645, 3792
 3795,
*Elset, elset=__PickedSurf16_S5, internal, instance=PART-3-1-1
  512,  532,  552,  572,  592,  612,  646,  650,  673,  709,  713,  736,  772,  776,  799,  835
  839,  862,  898,  902,  925,  961,  965,  988,  993,  994,  999, 1027, 1028, 1033, 1061, 1062
 1067, 1095, 1096, 1101, 1129, 1130, 1135, 1163, 1164, 1169, 1197, 1238, 1378, 1419, 1559, 1600
 1740, 1781, 1921, 1962, 2102, 2143, 2327, 2328, 2338, 2339, 2340, 2341, 2410, 2411, 2412, 2413
 2414, 2415, 2583, 2630, 2631, 2641, 2642, 2643, 2644, 2713, 2714, 2715, 2716, 2717, 2718, 2886
 2933, 2934, 2944, 2945, 2946, 2947, 3016, 3017, 3018, 3019, 3020, 3021, 3189, 3236, 3237, 3247
 3248, 3249, 3250, 3319, 3320, 3321, 3322, 3323, 3324, 3492, 3539, 3540, 3550, 3551, 3552, 3553
 3622, 3623, 3624, 3625, 3626, 3627, 3795
*Elset, elset=__PickedSurf16_S6, internal, instance=PART-3-1-1
  263,  277,  279,  281,  283,  297,  311,  313,  315,  317,  331,  345,  347,  349,  351,  365
  379,  381,  383,  385,  399,  413,  415,  417,  419,  421,  424,  433,  436,  445,  448,  457
  460,  469,  472,  481,  484,  657,  661,  665,  720,  724,  728,  783,  787,  791,  846,  850
  854,  909,  913,  917,  972,  976,  980, 1003, 1017, 1019, 1021, 1023, 1037, 1051, 1053, 1055
 1057, 1071, 1085, 1087, 1089, 1091, 1105, 1119, 1121, 1123, 1125, 1139, 1153, 1155, 1157, 1159
 1173, 1187, 1189, 1191, 1193, 1202, 1208, 1214, 1241, 1246, 1251, 1256, 1261, 1266, 1271, 1276
 1281, 1286, 1291, 1296, 1301, 1306, 1311, 1316, 1321, 1326, 1331, 1336, 1341, 1346, 1351, 1356
 1361, 1366, 1371, 1383, 1389, 1395, 1422, 1427, 1432, 1437, 1442, 1447, 1452, 1457, 1462, 1467
 1472, 1477, 1482, 1487, 1492, 1497, 1502, 1507, 1512, 1517, 1522, 1527, 1532, 1537, 1542, 1547
 1552, 1564, 1570, 1576, 1603, 1608, 1613, 1618, 1623, 1628, 1633, 1638, 1643, 1648, 1653, 1658
 1663, 1668, 1673, 1678, 1683, 1688, 1693, 1698, 1703, 1708, 1713, 1718, 1723, 1728, 1733, 1745
 1751, 1757, 1784, 1789, 1794, 1799, 1804, 1809, 1814, 1819, 1824, 1829, 1834, 1839, 1844, 1849
 1854, 1859, 1864, 1869, 1874, 1879, 1884, 1889, 1894, 1899, 1904, 1909, 1914, 1926, 1932, 1938
 1965, 1970, 1975, 1980, 1985, 1990, 1995, 2000, 2005, 2010, 2015, 2020, 2025, 2030, 2035, 2040
 2045, 2050, 2055, 2060, 2065, 2070, 2075, 2080, 2085, 2090, 2095, 2107, 2113, 2119, 2146, 2151
 2156, 2161, 2166, 2171, 2176, 2181, 2186, 2191, 2196, 2201, 2206, 2211, 2216, 2221, 2226, 2231
 2236, 2241, 2246, 2251, 2256, 2261, 2266, 2271, 2276, 2313, 2317, 2321, 2369, 2373, 2377, 2398
 2404, 2410, 2437, 2442, 2447, 2452, 2457, 2462, 2467, 2472, 2477, 2482, 2487, 2492, 2497, 2502
 2507, 2512, 2517, 2522, 2527, 2532, 2537, 2542, 2547, 2552, 2557, 2562, 2567, 2572, 2575, 2616
 2620, 2624, 2672, 2676, 2680, 2701, 2707, 2713, 2740, 2745, 2750, 2755, 2760, 2765, 2770, 2775
 2780, 2785, 2790, 2795, 2800, 2805, 2810, 2815, 2820, 2825, 2830, 2835, 2840, 2845, 2850, 2855
 2860, 2865, 2870, 2875, 2878, 2919, 2923, 2927, 2975, 2979, 2983, 3004, 3010, 3016, 3043, 3048
 3053, 3058, 3063, 3068, 3073, 3078, 3083, 3088, 3093, 3098, 3103, 3108, 3113, 3118, 3123, 3128
 3133, 3138, 3143, 3148, 3153, 3158, 3163, 3168, 3173, 3178, 3181, 3222, 3226, 3230, 3278, 3282
 3286, 3307, 3313, 3319, 3346, 3351, 3356, 3361, 3366, 3371, 3376, 3381, 3386, 3391, 3396, 3401
 3406, 3411, 3416, 3421, 3426, 3431, 3436, 3441, 3446, 3451, 3456, 3461, 3466, 3471, 3476, 3481
 3484, 3525, 3529, 3533, 3581, 3585, 3589, 3610, 3616, 3622, 3649, 3654, 3659, 3664, 3669, 3674
 3679, 3684, 3689, 3694, 3699, 3704, 3709, 3714, 3719, 3724, 3729, 3734, 3739, 3744, 3749, 3754
 3759, 3764, 3769, 3774, 3779, 3784, 3787
*Surface, type=ELEMENT, name=_PickedSurf16, internal
__PickedSurf16_S2, S2
__PickedSurf16_S3, S3
__PickedSurf16_S4, S4
__PickedSurf16_S6, S6
__PickedSurf16_S5, S5
*Elset, elset=__PickedSurf17_S2, internal, instance=PART-3-1-1
  97,  98,  99, 103, 104
*Elset, elset=__PickedSurf17_S3, internal, instance=PART-3-1-1
    1,    2,    5,    6,    9,   10,   13,   14,   89,   90,   93,   94,  117,  118,  119,  129
  130,  131,  132,  133,  134,  167,  168,  169,  170,  175,  176,  177,  178,  223,  224,  257
  291,  325,  359,  393,  642,  643,  705,  706,  768,  769,  831,  832,  894,  895,  957,  958
 1002, 1036, 1070, 1104, 1138, 1172, 2285, 2296, 2332, 2388, 2396, 2419, 2420, 2421, 2588, 2599
 2635, 2691, 2699, 2722, 2723, 2724, 2891, 2902, 2938, 2994, 3002, 3025, 3026, 3027, 3194, 3205
 3241, 3297, 3305, 3328, 3329, 3330, 3497, 3508, 3544, 3600, 3608, 3631, 3632, 3633
*Elset, elset=__PickedSurf17_S4, internal, instance=PART-3-1-1
   58,   60,   62,   64,   66,   68,   70,   72,   74,   76,   78,   80,  123,  124,  125,  160
  162,  164,  166,  218,  220,  222,  228,  230,  232,  234,  236,  238,  240,  242,  244,  246
  248,  250,  256,  264,  278,  280,  282,  284,  290,  298,  312,  314,  316,  318,  324,  332
  346,  348,  350,  352,  358,  366,  380,  382,  384,  386,  392,  400,  414,  416,  418,  420
  423,  426,  435,  438,  447,  450,  459,  462,  471,  474,  483,  486,  501,  502,  503,  507
  521,  522,  523,  527,  541,  542,  543,  547,  561,  562,  563,  567,  581,  582,  583,  587
  601,  602,  603,  607,  619,  682,  745,  808,  871,  934,  996, 1004, 1018, 1020, 1022, 1024
 1030, 1038, 1052, 1054, 1056, 1058, 1064, 1072, 1086, 1088, 1090, 1092, 1098, 1106, 1120, 1122
 1124, 1126, 1132, 1140, 1154, 1156, 1158, 1160, 1166, 1174, 1188, 1190, 1192, 1194, 1199, 1222
 1245, 1250, 1255, 1260, 1265, 1270, 1275, 1280, 1285, 1290, 1295, 1300, 1305, 1310, 1315, 1320
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*Elset, elset=__PickedSurf17_S5, internal, instance=PART-3-1-1
  262,  296,  330,  364,  398,  497,  508,  517,  528,  537,  548,  557,  568,  577,  588,  597
  608,  620,  683,  746,  809,  872,  935,  997, 1031, 1065, 1099, 1133, 1167, 1200, 1223, 1224
 1225, 1381, 1404, 1405, 1406, 1562, 1585, 1586, 1587, 1743, 1766, 1767, 1768, 1924, 1947, 1948
 1949, 2105, 2128, 2129, 2130, 2354, 2355, 2657, 2658, 2960, 2961, 3263, 3264, 3566, 3567
*Elset, elset=__PickedSurf17_S6, internal, instance=PART-3-1-1
  265,  269,  273,  299,  303,  307,  333,  337,  341,  367,  371,  375,  401,  405,  409,  427
  430,  439,  442,  451,  454,  463,  466,  475,  478,  487,  490,  493,  513,  533,  553,  573
  593, 1005, 1009, 1013, 1039, 1043, 1047, 1073, 1077, 1081, 1107, 1111, 1115, 1141, 1145, 1149
 1175, 1179, 1183, 2281, 2301, 2305, 2309, 2578, 2581, 2584, 2604, 2608, 2612, 2881, 2884, 2887
 2907, 2911, 2915, 3184, 3187, 3190, 3210, 3214, 3218, 3487, 3490, 3493, 3513, 3517, 3521, 3790
 3793,
*Surface, type=ELEMENT, name=_PickedSurf17, internal
__PickedSurf17_S2, S2
__PickedSurf17_S3, S3
__PickedSurf17_S4, S4
__PickedSurf17_S6, S6
__PickedSurf17_S5, S5
*End Assembly
**
** ELEMENT CONTROLS
**
*Section Controls, name=EC-1, hourglass=ENHANCED
1., 1., 1.
*Amplitude, name=Amp-1
             0.,              0.,           0.028,              1.
**
** MATERIALS
**
*Material, name="WEAK MATERIAL"
*Density
1100.,
*Elastic
 6.07e+07, 0.4
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=IntProp-1
1.,
*Friction
0.,
**
** INTERACTIONS
**
** Interaction: Int-1
*Contact Pair, interaction=IntProp-1, type=SURFACE TO SURFACE
_PickedSurf16, PART-2-1-1.m_Surf-1
** Interaction: Int-2
*Contact Pair, interaction=IntProp-1, type=SURFACE TO SURFACE
_PickedSurf17,
** ----------------------------------------------------------------
**
** STEP: Step-1
**
*Step, name=Step-1, nlgeom=YES, inc=1000
*Dynamic
0.0336,0.0336,3.36e-07
**
** BOUNDARY CONDITIONS
**
** Name: Fix Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet18, PINNED
** Name: vel Type: Velocity/Angular velocity
*Boundary, amplitude=Amp-1, type=VELOCITY
_PickedSet20, 1, 1, -0.25
** Name: vel_fix Type: Displacement/Rotation
*Boundary
_PickedSet21, 2, 2
_PickedSet21, 3, 3
_PickedSet21, 4, 4
_PickedSet21, 5, 5
_PickedSet21, 6, 6
** Name: zsymm Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet19, ZSYMM
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT, frequency=1
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
