*Heading
** Job name: SPH Model name: Model-1
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Case
*Node
      1,          -5.,          25.,           1.
      2,          -5.,           0.,           1.
      3,          -5.,           0.,           2.
      4,          -5.,          25.,           2.
      5,           0.,           0.,           1.
      6,           0.,           0.,           2.
      7,           0.,          25.,           2.
      8,           0.,          25.,           1.
      9,           0.,           0.,           0.
     10,          -5.,           0.,           0.
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*Element, type=C3D8R
1,  8, 63, 64,  7,  1, 49, 58,  4
2, 63, 62, 65, 64, 49, 50, 57, 58
3, 62, 61, 66, 65, 50, 51, 56, 57
4, 61, 60, 67, 66, 51, 52, 55, 56
5, 60, 59, 68, 67, 52, 53, 54, 55
6, 59,  5,  6, 68, 53,  2,  3, 54
7, 14, 11, 12, 13,  2,  5,  9, 10
 8,  11, 125, 126,  12,   5,  69, 106,   9
 9, 125, 124, 127, 126,  69,  70, 105, 106
10, 124, 123, 128, 127,  70,  71, 104, 105
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*Nset, nset=_PickedSet9, internal, generate
   1,  736,    1
*Elset, elset=_PickedSet9, internal, generate
   1,  342,    1
** Section: Plate
*Solid Section, elset=_PickedSet9, material=Steel
,
*End Part
**
*Part, name=Particle
*Node
      1,          40.,         12.5,           1.
      2,          40.,    10.416667,           1.
      3,          40.,   8.33333302,           1.
      4,          40.,         6.25,           1.
      5,          40.,   4.16666651,           1.
      6,          40.,   2.08333325,           1.
      7,          40.,           0.,           1.
      8,          40.,         12.5,           0.
      9,          40.,    10.416667,           0.
     10,          40.,   8.33333302,           0.
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*Element, type=C3D8R
  1,  15,  16,  23,  22,   1,   2,   9,   8
  2,  16,  17,  24,  23,   2,   3,  10,   9
  3,  17,  18,  25,  24,   3,   4,  11,  10
  4,  18,  19,  26,  25,   4,   5,  12,  11
  5,  19,  20,  27,  26,   5,   6,  13,  12
  6,  20,  21,  28,  27,   6,   7,  14,  13
  7,  29,  30,  37,  36,  15,  16,  23,  22
  8,  30,  31,  38,  37,  16,  17,  24,  23
  9,  31,  32,  39,  38,  17,  18,  25,  24
 10,  32,  33,  40,  39,  18,  19,  26,  25
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*Nset, nset=_PickedSet2, internal, generate
   1,  294,    1
*Elset, elset=_PickedSet2, internal, generate
   1,  120,    1
** Section: SPH
*Solid Section, elset=_PickedSet2, controls=EC-1, material=Water
,
*End Part
**
*Part, name=Plate
*Node
      1,          45.,          25.,           1.
      2,          45.,   24.0277786,           1.
      3,          45.,   23.0555553,           1.
      4,          45.,    22.083334,           1.
      5,          45.,   21.1111107,           1.
      6,          45.,   20.1388893,           1.
      7,          45.,    19.166666,           1.
      8,          45.,   18.1944447,           1.
      9,          45.,   17.2222214,           1.
     10,          45.,        16.25,           1.
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*Element, type=C3D8R
 1,  39,  40,  59,  58,   1,   2,  21,  20
 2,  40,  41,  60,  59,   2,   3,  22,  21
 3,  41,  42,  61,  60,   3,   4,  23,  22
 4,  42,  43,  62,  61,   4,   5,  24,  23
 5,  43,  44,  63,  62,   5,   6,  25,  24
 6,  44,  45,  64,  63,   6,   7,  26,  25
 7,  45,  46,  65,  64,   7,   8,  27,  26
 8,  46,  47,  66,  65,   8,   9,  28,  27
 9,  47,  48,  67,  66,   9,  10,  29,  28
10,  48,  49,  68,  67,  10,  11,  30,  29
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*Nset, nset=_PickedSet2, internal, generate
   1,  228,    1
*Elset, elset=_PickedSet2, internal, generate
  1,  90,   1
** Section: Plate
*Solid Section, elset=_PickedSet2, material=Steel
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Case-1, part=Case
*End Instance
**
*Instance, name=Particle-1, part=Particle
*End Instance
**
*Instance, name=Plate-1, part=Plate
*End Instance
**
*Node
      1,          -5.,          -5.,           2.
*Nset, nset=_PickedSet9, internal
 1,
*Nset, nset=_PickedSet10, internal, instance=Case-1, generate
   1,  736,    1
*Elset, elset=_PickedSet10, internal, instance=Case-1, generate
   1,  342,    1
*Nset, nset=_PickedSet11, internal
 1,
*Nset, nset=_PickedSet12, internal, instance=Plate-1, generate
   1,  210,   19
*Elset, elset=_PickedSet12, internal, instance=Plate-1, generate
  1,  73,  18
** Constraint: Constraint-1
*Rigid Body, ref node=_PickedSet9, elset=_PickedSet10
*End Assembly
**
** ELEMENT CONTROLS
**
*Section Controls, name=EC-1, ELEMENT CONVERSION=YES, CONVERSION CRITERION=TIME, KERNEL=CUBIC
1., 1., 1.


2, 0.
**
** MATERIALS
**
*Material, name=Steel
*Density
7800.,
*Elastic
 2e+11, 0.3
*Material, name=Water
*Density
998.,
*Eos, type=USUP
1500.,0.,0.
*Viscosity
 1.26765e-05,
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=nofric
*Friction
0.,
** ----------------------------------------------------------------
**
** STEP: Step-1
**
*Step, name=Step-1, nlgeom=YES
*Dynamic, Explicit
, 5.
*Bulk Viscosity
0.06, 1.2
**
** BOUNDARY CONDITIONS
**
** Name: Plate-fix Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet12, PINNED
** Name: fix Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet11, ENCASTRE
**
** LOADS
**
** Name: Gravity   Type: Gravity
*Dload
, GRAV, 9.81, 0., -1., 0.
**
** INTERACTIONS
**
** Interaction: general
*Contact, op=NEW
*Contact Inclusions, ALL EXTERIOR
*Contact Property Assignment
 ,  , nofric
**
** OUTPUT REQUESTS
**
*Restart, write, number interval=1, time marks=NO
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
