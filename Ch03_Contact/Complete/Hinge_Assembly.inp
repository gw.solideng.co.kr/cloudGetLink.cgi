*Heading
** Job name: Hinge_assembly Model name: Model-1
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Hinge_Hole
*Node
      1,          60.,          -8.,           0.
      2,          60.,          -8.,         -20.
      3,          72.,         -20.,         -20.
      4,          72.,         -20.,           0.
      5,          60.,           0.,         -20.
      6,          80.,         -20.,         -20.
      7,          80.,         -20.,           0.
      8,          60.,           0.,           0.
      9,          60.,         -32.,           0.
     10,          60.,         -40.,           0.
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*Element, type=C3D8R
 1,  64, 304, 947, 294,   1,  27, 254,  44
 2, 304, 305, 948, 947,  27,  28, 255, 254
 3, 305, 306, 949, 948,  28,  29, 256, 255
 4, 306, 307, 950, 949,  29,  30, 257, 256
 5, 307,  66, 299, 950,  30,   2,  31, 257
 6, 294, 947, 951, 295,  44, 254, 258,  43
 7, 947, 948, 952, 951, 254, 255, 259, 258
 8, 948, 949, 953, 952, 255, 256, 260, 259
 9, 949, 950, 954, 953, 256, 257, 261, 260
10, 950, 299, 300, 954, 257,  31,  32, 261
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*Nset, nset=Set-1, generate
    1,  1787,     1
*Elset, elset=Set-1, generate
    1,  1300,     1
** Section: Section-1
*Solid Section, elset=Set-1, material=Steel
,
*End Part
**
*Part, name=Pin
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Hinge_Hole-1, part=Hinge_Hole
*End Instance
**
*Instance, name=Hinge_Hole-2, part=Hinge_Hole
        120.,  -1.4210854715202e-14,         -40.
        120.,  -1.4210854715202e-14,         -40.,         120., 0.999999999999986,         -40.,         180.
*End Instance
**
*Instance, name=Pin-1, part=Pin
60.0000000000001,         -20.,         -20.
60.0000000000001,         -20.,         -20., 61.0000000000001,         -20.,         -20.,          90.
*Node
      1,          12.,          30.,           0.
*Nset, nset=Pin-1-RefPt_, internal
1,
*Surface, type=REVOLUTION, name=Pin
START,          12.,          30.
 LINE,          12.,         -30.
*Rigid Body, ref node=Pin-1-RefPt_, analytical surface=Pin
*End Instance
**
*Nset, nset=Set-1, instance=Hinge_Hole-2
  23,  24,  25,  26, 166, 167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 177
 178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 193
 194, 195, 196, 197, 198, 199, 200, 201, 492, 493, 494, 495, 496, 497, 498, 499
 500, 501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 515
 516, 517, 518, 519, 520, 521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 531
 532, 533, 534, 535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 545, 546, 547
 548, 549, 550, 551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 563
 564, 565, 566, 567, 568, 569, 570, 571, 572
*Elset, elset=Set-1, instance=Hinge_Hole-2, generate
 1111,  1210,     1
*Nset, nset=Set-2, instance=Pin-1
 1,
*Nset, nset=Set-3, instance=Hinge_Hole-2
 20,
*Nset, nset=Set-4, instance=Hinge_Hole-2
  23,  24,  25,  26, 166, 167, 168, 169, 170, 171, 172, 173, 174, 175, 176, 177
 178, 179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 193
 194, 195, 196, 197, 198, 199, 200, 201, 492, 493, 494, 495, 496, 497, 498, 499
 500, 501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 513, 514, 515
 516, 517, 518, 519, 520, 521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 531
 532, 533, 534, 535, 536, 537, 538, 539, 540, 541, 542, 543, 544, 545, 546, 547
 548, 549, 550, 551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 563
 564, 565, 566, 567, 568, 569, 570, 571, 572
*Elset, elset=Set-4, instance=Hinge_Hole-2, generate
 1111,  1210,     1
*Elset, elset=_Hinge_Hole-1_Hole_S4, internal, instance=Hinge_Hole-1
   77,   78,   79,   80, 1251, 1252, 1253, 1254, 1255, 1256, 1257, 1258, 1285, 1286, 1287, 1288
 1295, 1296, 1297, 1298, 1299, 1300
*Elset, elset=_Hinge_Hole-1_Hole_S3, internal, instance=Hinge_Hole-1
   61,   62,   63,   64,   65,   66,   81,   82,   83,   84,   85,   86,   87,   88,   89,   90
   91,   92, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270
*Elset, elset=_Hinge_Hole-1_Hole_S2, internal, instance=Hinge_Hole-1
   1,   2,   3,   4,   5,   6,   7,   8,   9,  10,  11,  12,  13,  14,  15,  16
  17,  18,  19,  20,  21,  22,  23,  24,  25,  26,  27,  28,  29,  30, 123, 124
 125, 126, 127, 128, 129, 130
*Elset, elset=_Hinge_Hole-1_Hole_S6, internal, instance=Hinge_Hole-1, generate
 151,  209,    2
*Surface, type=ELEMENT, name=Hinge_Hole-1_Hole
_Hinge_Hole-1_Hole_S4, S4
_Hinge_Hole-1_Hole_S3, S3
_Hinge_Hole-1_Hole_S2, S2
_Hinge_Hole-1_Hole_S6, S6
*Elset, elset=_Hinge_Hole-1_Lateral_S4, internal, instance=Hinge_Hole-1
    5,   10,   15,   20,   25,   30,   35,   40,   45,   50,   55,   60,   74,   76, 1236, 1238
 1240, 1242, 1244, 1246, 1248, 1250, 1272, 1274
*Elset, elset=_Hinge_Hole-1_Lateral_S3, internal, instance=Hinge_Hole-1
   77,   79,  123,  124,  125,  126,  151,  152,  161,  162,  171,  172,  181,  182,  191,  192
  201,  202, 1251, 1253, 1255, 1257
*Elset, elset=_Hinge_Hole-1_Lateral_S2, internal, instance=Hinge_Hole-1
  131,  132,  135,  136,  137,  138,  139,  140,  141,  142, 1281, 1282, 1285, 1286
*Surface, type=ELEMENT, name=Hinge_Hole-1_Lateral
_Hinge_Hole-1_Lateral_S4, S4
_Hinge_Hole-1_Lateral_S3, S3
_Hinge_Hole-1_Lateral_S2, S2
*Elset, elset=_Hinge_Hole-2_Hole_S4, internal, instance=Hinge_Hole-2
   77,   78,   79,   80, 1251, 1252, 1253, 1254, 1255, 1256, 1257, 1258, 1285, 1286, 1287, 1288
 1295, 1296, 1297, 1298, 1299, 1300
*Elset, elset=_Hinge_Hole-2_Hole_S3, internal, instance=Hinge_Hole-2
   61,   62,   63,   64,   65,   66,   81,   82,   83,   84,   85,   86,   87,   88,   89,   90
   91,   92, 1259, 1260, 1261, 1262, 1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270
*Elset, elset=_Hinge_Hole-2_Hole_S2, internal, instance=Hinge_Hole-2
   1,   2,   3,   4,   5,   6,   7,   8,   9,  10,  11,  12,  13,  14,  15,  16
  17,  18,  19,  20,  21,  22,  23,  24,  25,  26,  27,  28,  29,  30, 123, 124
 125, 126, 127, 128, 129, 130
*Elset, elset=_Hinge_Hole-2_Hole_S6, internal, instance=Hinge_Hole-2, generate
 151,  209,    2
*Surface, type=ELEMENT, name=Hinge_Hole-2_Hole
_Hinge_Hole-2_Hole_S4, S4
_Hinge_Hole-2_Hole_S3, S3
_Hinge_Hole-2_Hole_S2, S2
_Hinge_Hole-2_Hole_S6, S6
*Elset, elset=_Hinge_Hole-2_Lateral_S4, internal, instance=Hinge_Hole-2
    5,   10,   15,   20,   25,   30,   35,   40,   45,   50,   55,   60,   74,   76, 1236, 1238
 1240, 1242, 1244, 1246, 1248, 1250, 1272, 1274
*Elset, elset=_Hinge_Hole-2_Lateral_S3, internal, instance=Hinge_Hole-2
   77,   79,  123,  124,  125,  126,  151,  152,  161,  162,  171,  172,  181,  182,  191,  192
  201,  202, 1251, 1253, 1255, 1257
*Elset, elset=_Hinge_Hole-2_Lateral_S2, internal, instance=Hinge_Hole-2
  131,  132,  135,  136,  137,  138,  139,  140,  141,  142, 1281, 1282, 1285, 1286
*Surface, type=ELEMENT, name=Hinge_Hole-2_Lateral
_Hinge_Hole-2_Lateral_S4, S4
_Hinge_Hole-2_Lateral_S3, S3
_Hinge_Hole-2_Lateral_S2, S2
*Elset, elset=_Surf-6_S1, internal, instance=Hinge_Hole-1, generate
 1111,  1210,     1
*Surface, type=ELEMENT, name=Surf-6
_Surf-6_S1, S1
*End Assembly
**
** MATERIALS
**
*Material, name=Steel
*Elastic
210000., 0.3
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=friction
1.,
*Friction, slip tolerance=0.005
 0.3,
**
** BOUNDARY CONDITIONS
**
** Name: Fixed Type: Displacement/Rotation
*Boundary
Set-1, 1, 1
Set-1, 2, 2
Set-1, 3, 3
** Name: NoSlip Type: Displacement/Rotation
*Boundary
Set-2, 2, 2
Set-2, 3, 3
Set-2, 4, 4
Set-2, 6, 6
**
** INTERACTIONS
**
** Interaction: Hole-1_And_Hole-2
*Contact Pair, interaction=friction, type=SURFACE TO SURFACE
Hinge_Hole-2_Lateral, Hinge_Hole-1_Lateral
** Interaction: Hole-1_And_Pin
*Contact Pair, interaction=friction
Hinge_Hole-1_Hole, Pin-1.Pin
** Interaction: Hole-2_And_Pin
*Contact Pair, interaction=friction
Hinge_Hole-2_Hole, Pin-1.Pin
** ----------------------------------------------------------------
**
** STEP: Contact
**
*Step, name=Contact, nlgeom=YES
Hinge_Assembly
*Static
0.01, 1., 1e-05, 1.
**
** LOADS
**
** Name: Pressure   Type: Pressure
*Dsload
Surf-6, P, -1.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
