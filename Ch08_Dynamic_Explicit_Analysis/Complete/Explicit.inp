*Heading
** Job name: Pipe Model name: Model-1
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Pipe_Fix
*Node
      1,   1.00430524,   3.09093356,          25.
      2,   1.91030204,   2.62930512,          25.
      3,   2.62930512,   1.91030204,          25.
      4,   3.09093356,   1.00430524,          25.
      5,         3.25,           0.,          25.
      6,   3.09093356,  -1.00430524,          25.
      7,   2.62930512,  -1.91030204,          25.
      8,   1.91030204,  -2.62930512,          25.
      9,   1.00430524,  -3.09093356,          25.
     10,           0.,        -3.25,          25.
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*Element, type=S4R
  1,  20,   1,  21,  40
  2,   1,   2,  22,  21
  3,   2,   3,  23,  22
  4,   3,   4,  24,  23
  5,   4,   5,  25,  24
  6,   5,   6,  26,  25
  7,   6,   7,  27,  26
  8,   7,   8,  28,  27
  9,   8,   9,  29,  28
 10,   9,  10,  30,  29
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*Nset, nset=_PickedSet2, internal, generate
   1,  500,    1
*Elset, elset=_PickedSet2, internal, generate
   1,  480,    1
** Section: ShellSection
*Shell Section, elset=_PickedSet2, material=Steel
0.432, 5
*End Part
**
*Part, name=Pipe_Impacting
*Node
      1,           0.,         3.25,          50.
      2,   1.00430524,   3.09093356,          50.
      3,   1.91030204,   2.62930512,          50.
      4,   2.62930512,   1.91030204,          50.
      5,   3.09093356,   1.00430524,          50.
      6,         3.25,           0.,          50.
      7,   3.09093356,  -1.00430524,          50.
      8,   2.62930512,  -1.91030204,          50.
      9,   1.91030204,  -2.62930512,          50.
     10,   1.00430524,  -3.09093356,          50.
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*Element, type=S4R
  1,   1,   2,  13,  12
  2,   2,   3,  14,  13
  3,   3,   4,  15,  14
  4,   4,   5,  16,  15
  5,   5,   6,  17,  16
  6,   6,   7,  18,  17
  7,   7,   8,  19,  18
  8,   8,   9,  20,  19
  9,   9,  10,  21,  20
 10,  10,  11,  22,  21
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*Nset, nset=_PickedSet2, internal, generate
   1,  561,    1
*Elset, elset=_PickedSet2, internal, generate
   1,  500,    1
** Section: ShellSection
*Shell Section, elset=_PickedSet2, material=Steel
0.432, 5
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Pipe_Fix-1, part=Pipe_Fix
*End Instance
**
*Instance, name=Pipe_Impacting-1, part=Pipe_Impacting
        -25.,        6.932,          25.
        -25.,        6.932,          25.,         -25.,        7.932,          25.,          90.
*End Instance
**
*Node
      1,          25.,   6.93200016,          25.
*Nset, nset=_PickedSet7, internal
 1,
*Nset, nset=_PickedSet8, internal, instance=Pipe_Impacting-1, generate
  1,  11,   1
*Elset, elset=_PickedSet8, internal, instance=Pipe_Impacting-1, generate
  1,  10,   1
*Nset, nset=_PickedSet9, internal, instance=Pipe_Fix-1, generate
  1,  20,   1
*Elset, elset=_PickedSet9, internal, instance=Pipe_Fix-1, generate
  1,  20,   1
*Nset, nset=_PickedSet10, internal, instance=Pipe_Impacting-1
   1,  11,  12,  22,  23,  33,  34,  44,  45,  55,  56,  66,  67,  77,  78,  88
  89,  99, 100, 110, 111, 121, 122, 132, 133, 143, 144, 154, 155, 165, 166, 176
 177, 187, 188, 198, 199, 209, 210, 220, 221, 231, 232, 242, 243, 253, 254, 264
 265, 275, 276, 286, 287, 297, 298, 308, 309, 319, 320, 330, 331, 341, 342, 352
 353, 363, 364, 374, 375, 385, 386, 396, 397, 407, 408, 418, 419, 429, 430, 440
 441, 451, 452, 462, 463, 473, 474, 484, 485, 495, 496, 506, 507, 517, 518, 528
 529, 539, 540, 550, 551, 561
*Elset, elset=_PickedSet10, internal, instance=Pipe_Impacting-1
   1,  10,  11,  20,  21,  30,  31,  40,  41,  50,  51,  60,  61,  70,  71,  80
  81,  90,  91, 100, 101, 110, 111, 120, 121, 130, 131, 140, 141, 150, 151, 160
 161, 170, 171, 180, 181, 190, 191, 200, 201, 210, 211, 220, 221, 230, 231, 240
 241, 250, 251, 260, 261, 270, 271, 280, 281, 290, 291, 300, 301, 310, 311, 320
 321, 330, 331, 340, 341, 350, 351, 360, 361, 370, 371, 380, 381, 390, 391, 400
 401, 410, 411, 420, 421, 430, 431, 440, 441, 450, 451, 460, 461, 470, 471, 480
 481, 490, 491, 500
*Nset, nset=_PickedSet11, internal, instance=Pipe_Fix-1, generate
 481,  500,    1
*Elset, elset=_PickedSet11, internal, instance=Pipe_Fix-1, generate
 461,  480,    1
*Nset, nset=_PickedSet12, internal
 1,
*Nset, nset=_PickedSet13, internal, instance=Pipe_Impacting-1, generate
   1,  561,    1
*Elset, elset=_PickedSet13, internal, instance=Pipe_Impacting-1, generate
   1,  500,    1
** Constraint: Constraint-1
*Rigid Body, ref node=_PickedSet7, tie nset=_PickedSet8
*End Assembly
**
** MATERIALS
**
*Material, name=Steel
*Density
 0.000732,
*Elastic
 3e+07, 0.3
*Plastic
45000.,0.
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=IntProp-1
*Friction
 0.2,
**
** BOUNDARY CONDITIONS
**
** Name: BC-1 Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet9, ZSYMM
** Name: BC-2 Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet10, ZSYMM
** Name: BC-3 Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet11, ENCASTRE
** Name: BC-4 Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet12, PINNED
**
** PREDEFINED FIELDS
**
** Name: Predefined Field-1   Type: Velocity
*Initial Conditions, type=ROTATING VELOCITY
_PickedSet13, 75., 0., 0., 0.,
25., 6.932, 21.75, 25., 6.932, 25.,
**
** INTERACTIONS
**
** Interaction: Int-1
*Contact, op=NEW
*Contact Inclusions, ALL EXTERIOR
*Contact Property Assignment
 ,  , IntProp-1
** ----------------------------------------------------------------
**
** STEP: Pipe_Impacting
**
*Step, name=Pipe_Impacting, nlgeom=YES
*Dynamic, Explicit
, 0.015
*Bulk Viscosity
0.06, 1.2
**
** OUTPUT REQUESTS
**
*Restart, write, number interval=1, time marks=NO
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
