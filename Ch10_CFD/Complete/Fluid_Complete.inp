*Heading
** Job name: Fluid_Test Model name: Model-1
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Part-1
*Node
      1,         -50.,         -30.,          20.
      2,         -50.,          30.,          20.
      3,         -50.,          30.,           0.
      4,         -50.,         -30.,           0.
      5,          10.,           0.,          20.
      6,          10.,           0.,           0.
      7,          50.,          30.,          20.
      8,          50.,          30.,           0.
      9,          50.,         -30.,           0.
     10,          50.,         -30.,          20.
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*Element, type=FC3D4
    1,  4854,  4855,  4856,  4857
    2,  4858,  4854,  4855,  4856
    3,  4859,  4860,  4855,  4861
    4,  4862,  4863,  4864,  4865
    5,  4857,  4866,  4861,  4860
    6,  4857,  4860,  4855,  4867
    7,  4857,  4856,  4860,  4867
    8,  4868,  4869,  2055,  4870
    9,  4871,  4872,  4873,  4874
   10,  4875,  3751,  4876,  4877
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*Nset, nset=Set-1, generate
     1,  16864,      1
*Elset, elset=Set-1, generate
     1,  86856,      1
** Section: Section-1
*Fluid Section, type=SINGLE FLUID, elset=Set-1
Air,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Part-1-1, part=Part-1
*End Instance
**
*Elset, elset=_Surf-1_S3, internal, instance=Part-1-1
    75,   283,   420,   466,   548,   566,   686,  1206,  1207,  1484,  1601,  1622,  1794,  1951,  1978,  2069
  2256,  2352,  2383,  2692,  2918,  3100,  3184,  3890,  4188,  4345,  4918,  5017,  5032,  5093,  5370,  5596
  5886,  6043,  6414,  6549,  6870,  7118,  7127,  7198,  7475,  7479,  7547,  7573,  7574,  7581,  7583,  8315
  8795,  8983, 12532, 12770, 12843, 13037, 13211, 13234, 13465, 13481, 13572, 13727, 13732, 13970, 14220, 14568
 15332, 15525, 15566, 15592, 15602, 15610, 15628, 16159, 17836, 17843, 17868, 17907, 17940, 17975, 18236, 18266
 18272, 18340, 18344, 18351, 18356, 18374, 18384, 18387, 18415, 18418, 18421, 18430, 18441, 18444, 18459, 18461
 18485, 18524, 18526, 18533, 18610, 18611, 18615, 18625, 18635, 18725, 18811, 18836, 18911, 18958, 18964, 18975
 19013, 19014, 19338, 19959, 19974, 19986, 19988, 19992, 20006, 20036, 20235, 20607, 20761, 20766, 21233, 21259
 21408, 21758, 21772, 21777, 21782, 21789, 21889, 21890, 21921, 22096, 22513, 22858, 22915, 23117, 23200, 23334
 23463, 23468, 23532, 23720, 23748, 23859, 23873, 23985, 24006, 24249, 24255, 24271, 24275, 24542, 25066, 25633
 25654, 26266, 26619, 26650, 26651, 26952, 26974, 26976, 26983, 26990, 27008, 27264, 27265, 27574, 27586, 27600
 27621, 27622, 27636, 27654, 28445, 28582, 28595, 28614, 28621, 28622, 28650, 28690, 28697, 28720, 28721, 28725
 29000, 29011, 29061, 29066, 29131, 29140, 29151, 29192, 29194, 29220, 29889, 31297, 31326, 31340, 31342, 31349
 31609, 31627, 32665, 32667, 32947, 33155, 33160, 33224, 33228, 33321, 33766, 33785, 33804, 33824, 33827, 33833
 33846, 33868, 33892, 33909, 33934, 33935, 33936, 33941, 33945, 33951, 33955, 33959, 33964, 33967, 33969, 33973
 33986, 33987, 33989, 33998, 34006, 34009, 34013, 34017, 34021, 34033, 34038, 34050, 34051, 34056, 34064, 34067
 34069, 34071, 34078, 34086, 34087, 34089, 34092, 34108, 34109, 34112, 34122, 34132, 34148, 34155, 34156, 34157
 34163, 34166, 34170, 34178, 34181, 34184, 34188, 34192, 34194, 34197, 34199, 34203, 34206, 34209, 34217, 34219
 34222, 34225, 34231, 34232, 34233, 34250, 34251, 34254, 34257, 34260, 34263, 34264, 34272, 34281, 34287, 34295
 34301, 34302, 34304, 34311, 34312, 34313, 34324, 34333, 34339, 34341, 34348, 34352, 34353, 34355, 34362, 34366
 34371, 34374, 34375, 34377, 34382, 34384, 34389, 34393, 34395, 34399, 34401, 34405, 34414, 34415, 34416, 34417
 34421, 34423, 34430, 34438, 34445, 34453, 34462, 34463, 34476, 34495, 34496, 34501, 34507, 34511, 34523, 34528
 34531, 34536, 34538, 34540, 34549, 34565, 34567, 34568, 34569, 34571, 34572, 34580, 34582, 34583, 34585, 34605
 34608, 34611, 34621, 34622, 34624, 34630, 34635, 34648, 34651, 34656, 34658, 34660, 34668, 34687, 34689, 34695
 34701, 34703, 34710, 34712, 34717, 34729, 34731, 34735, 34737, 34739, 34749, 34761, 34769, 34770, 34791, 34792
 34800, 34805, 34807, 34808, 34809, 34816, 34818, 34826, 34829, 34831, 34832, 34843, 34852, 34853, 34856, 34860
 34861, 34862, 34863, 34874, 34880, 34884, 34885, 34887, 34891, 34895, 34909, 34911, 34912, 34913, 34914, 34917
 34919, 34944, 34950, 34954, 34956, 34969, 34972, 34973, 34976, 34977, 34978, 34979, 34984, 35014, 35221, 35590
 35943, 36141, 36324, 36471, 36731, 36976, 36980, 36981, 37960, 38113, 40323, 40534, 40540, 41758, 42486, 43271
 43348, 45052, 46092, 46934, 47946, 47947, 49335, 50803, 51178, 51181, 53109, 53110, 57636
*Elset, elset=_Surf-1_S4, internal, instance=Part-1-1
   291,  1087,  3136, 18361, 18489, 18733, 18735, 18812, 18904, 26648, 26957, 26997, 28583, 28611, 29100, 29225
 33768, 33902, 34485, 34764, 34776, 34783, 34850, 37241, 45813, 48142, 52618, 54158, 67552, 67554, 68618, 72347
 72983, 83732
*Elset, elset=_Surf-1_S1, internal, instance=Part-1-1
   441,   791,  1009,  1193,  1582,  1984,  2318,  2325,  2770,  2919,  3311,  3694,  3871,  4066,  4428,  4456
  6149,  6498, 10718, 14636, 15629, 18471, 18833, 18917, 24250, 26993, 28580, 28713, 29015, 29180, 29236, 31341
 33020, 33810, 33831, 33842, 33855, 33860, 33886, 33890, 33903, 33908
*Elset, elset=_Surf-1_S2, internal, instance=Part-1-1
  1200,  2189,  6776,  6990,  7531, 15609, 18241, 18455, 18511, 18736, 21407, 26633, 27610, 28467, 28606, 28668
 28673, 28677, 28696, 28705, 28715, 29172, 29201, 29219, 33786, 33794, 33802, 33821, 33839, 33851, 33859, 33865
 33891, 33897, 33906, 33914, 33924, 33949, 33952, 34230, 34280, 34292, 34529, 34666, 34906, 34938, 35520
*Surface, type=ELEMENT, name=Surf-1
_Surf-1_S3, S3
_Surf-1_S4, S4
_Surf-1_S2, S2
_Surf-1_S1, S1
*Elset, elset=_Surf-2_S3, internal, instance=Part-1-1
   325,  1833,  2355,  3210,  4624,  5428,  6444,  6494,  6511,  6574,  6579,  6592,  6596,  6602,  6609,  6611
  6619,  6638,  6687,  6689,  6730,  6731,  6850,  6913,  6916,  6955,  6960,  6961,  6964,  6975,  6977,  6983
  7065,  7068,  7072,  7085,  7172,  7173,  7257,  7285,  7336,  7428,  7431,  7434,  7586,  7599,  7613,  7639
  7641,  7654,  7655,  7662,  7667,  7669,  7670,  7673,  7678,  7681,  7682,  7694,  7705,  7709,  7719,  7720
  7732,  7733,  7739,  7747,  7755,  7757,  7765,  7766,  7768,  7779,  7793,  7795,  7806,  7807,  7831,  7832
  7833,  7837,  7843,  7844,  7848,  7856,  7860,  7863,  7869,  7883,  7895,  7904,  7914,  7920,  7923,  7933
  7936,  7941,  7948,  7949,  7956,  7965,  7980,  7992,  7997,  7998,  8001,  8009,  8011,  8012,  8018,  8019
  8020,  8021,  8022,  8031,  8037,  8038,  8041,  8045,  8046,  8047,  8053,  8056,  8061,  8065,  8066,  8072
  8076,  8077,  8080,  8081,  8089,  8094,  8097,  8099,  8101,  8105,  8114,  8116,  8120,  8123,  8135,  8148
  8149,  8150,  8158,  8159,  8162,  8164,  8178,  8180,  8181,  8182,  8183,  8193,  8194,  8195,  8205,  8206
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*Elset, elset=_Surf-2_S2, internal, instance=Part-1-1
  4760,  7659,  7942,  8029,  8068,  8225,  8517,  8676,  8750,  8960,  9003,  9040,  9113,  9117, 14786, 16279
 16368, 17009, 29972, 32512
*Elset, elset=_Surf-2_S4, internal, instance=Part-1-1
  7605,  7622,  7866,  7892,  8237,  8689,  8783,  9246, 12285, 14902, 16748, 20720, 21941, 29631, 39638, 43200
 43804, 51465, 60535, 66738
*Elset, elset=_Surf-2_S1, internal, instance=Part-1-1
  7896, 49445, 54618, 63072, 78071
*Surface, type=ELEMENT, name=Surf-2
_Surf-2_S3, S3
_Surf-2_S2, S2
_Surf-2_S4, S4
_Surf-2_S1, S1
*Elset, elset=_Surf-3_S3, internal, instance=Part-1-1
   290,   336,   413,   626,   676,   699,   864,   910,  1187,  1417,  1846,  1932,  2188,  2326,  2472,  2553
  2597,  2798,  2802,  2895,  2897,  2917,  3081,  3133,  3175,  3181,  3378,  3753,  3795,  3971,  4203,  4300
  4720,  4762,  4845,  4916,  5270,  5285,  5421,  5515,  5678,  5821,  5885,  5896,  5966,  6334,  6501,  6503
  6505,  6506,  6509,  6513,  6519,  6522,  6531,  6539,  6543,  6544,  6578,  6580,  6585,  6591,  6621,  6629
  6631,  6632,  6640,  6644,  6645,  6652,  6657,  6658,  6665,  6667,  6668,  6669,  6675,  6679,  6680,  6690
  6700,  6703,  6705,  6711,  6732,  6738,  6739,  6742,  6745,  6748,  6753,  6764,  6771,  6772,  6779,  6782
  6795,  6800,  6804,  6810,  6816,  6818,  6822,  6823,  6827,  6828,  6829,  6831,  6834,  6842,  6858,  6864
  6874,  6878,  6895,  6897,  6898,  6899,  6912,  6922,  6924,  6925,  6928,  6929,  6933,  6935,  6945,  6947
  6951,  6959,  6965,  6969,  6971,  6984,  6997,  7002,  7003,  7005,  7008,  7011,  7013,  7016,  7017,  7021
  7028,  7029,  7035,  7038,  7041,  7046,  7048,  7049,  7060,  7066,  7074,  7075,  7079,  7088,  7094,  7095
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*Elset, elset=_Surf-3_S4, internal, instance=Part-1-1
   397,  1846,  3209,  4427,  6698,  6731,  6742,  6751,  6752,  6853,  6860,  6897,  7041,  7260,  7276,  7412
  7446,  7573,  7616,  7669,  7670,  7757,  7768,  7780,  7832,  7848,  7869,  7923,  8138,  8153,  8263,  8795
  9039,  9232,  9276,  9326,  9407,  9423,  9470,  9519,  9541,  9599,  9615,  9656,  9684,  9745,  9807,  9844
 10013, 10083, 10157, 10206, 10288, 10450, 10589, 10675, 10695, 10704, 10807, 10821, 10938, 11040, 11065, 11066
 11150, 11263, 11300, 11339, 11349, 11524, 11562, 11667, 11684, 11702, 11755, 11772, 11857, 11919, 11960, 11961
 12039, 12052, 12119, 12137, 12187, 12813, 12860, 13128, 13141, 13214, 13336, 13581, 13606, 13633, 13688, 13842
 13955, 13970, 14228, 14237, 14252, 14700, 14706, 14731, 14808, 14844, 14999, 15118, 15130, 15190, 15207, 15249
 15255, 15314, 15370, 15382, 15390, 15481, 15507, 15527, 15767, 15770, 15772, 15921, 16017, 16050, 16053, 16065
 16098, 16245, 16285, 16294, 16325, 16335, 16382, 16419, 16428, 16507, 16718, 16805, 17379, 17526, 17914, 17950
 18123, 18204, 18299, 18340, 18461, 18485, 18610, 18615, 18715, 18894, 18915, 19036, 19072, 19132, 19179, 19228
 19337, 19463, 19482, 19600, 20032, 20336, 20851, 20930, 21003, 21512, 21639, 21755, 21772, 21777, 22063, 22192
 22229, 22500, 22594, 22614, 22618, 22739, 22764, 22769, 22809, 22825, 22837, 22860, 22947, 22969, 23014, 23105
 23217, 23289, 23368, 23522, 23528, 23646, 23785, 23823, 23967, 24021, 24144, 24148, 24207, 24323, 24597, 24769
 25113, 25178, 25190, 25208, 25224, 25242, 25272, 25288, 25294, 25321, 25356, 25379, 25473, 25480, 25482, 25511
 25530, 25541, 25542, 25601, 25602, 25671, 25734, 25794, 25948, 26005, 26165, 26188, 26197, 26243, 26527, 26887
 26888, 27101, 27116, 27122, 27222, 27394, 27482, 27483, 27691, 27710, 27839, 28036, 28163, 28172, 28271, 28325
 28371, 28387, 28564, 28907, 28922, 28969, 29066, 29372, 29477, 29557, 29754, 30011, 30276, 30523, 30582, 30632
 30832, 30856, 30997, 31193, 31566, 31668, 31723, 31828, 32058, 32362, 32446, 32448, 32603, 32987, 32990, 33421
 33502, 33584, 34162, 34399, 34472, 34511, 34565, 34863, 34912, 34979, 35032, 35053, 35409, 36144, 36196, 36286
 36430, 36667, 36887, 36908, 37487, 37565, 37667, 37796, 38213, 38326, 38451, 38557, 38733, 39054, 39072, 39087
 39532, 39589, 39813, 39879, 39890, 40193, 40566, 40994, 41841, 42335, 42345, 42442, 42664, 42713, 43129, 43216
 43305, 43528, 44305, 44751, 44761, 45212, 45242, 46343, 46894, 47002, 47024, 47465, 47532, 47758, 48328, 48396
 48777, 48827, 48944, 49010, 49507, 50429, 50431, 51818, 51983, 52542, 52617, 52647, 52774, 52898, 53052, 53197
 53345, 53536, 53802, 53989, 54296, 54565, 54653, 54663, 54752, 54981, 55070, 55437, 55470, 55482, 55763, 55945
 56422, 56426, 56660, 56791, 57419, 57491, 57627, 57781, 58081, 58107, 58393, 59450, 59757, 59795, 59818, 60107
 60196, 60201, 60205, 61243, 61837, 63818, 65745, 66446, 70313, 72491, 73388
*Elset, elset=_Surf-3_S1, internal, instance=Part-1-1
  6494,  6495,  6619,  6686,  6698,  6761,  6818,  7079,  7273,  7446,  7463,  7605,  7641,  7649,  7719,  7720
  7866,  7880,  8121,  8499,  8914,  8991,  9166,  9185,  9241,  9291,  9301,  9381,  9580,  9684,  9753,  9925
 10286, 10365, 10533, 11018, 11141, 11185, 11304, 11382, 11522, 11607, 11654, 11689, 11766, 11794, 11857, 11877
 12119, 12137, 12187, 12225, 12315, 12605, 13479, 13778, 13811, 14081, 14087, 14126, 14151, 14172, 14225, 14249
 14264, 14409, 14426, 14439, 14455, 14468, 14545, 14579, 14603, 14612, 14663, 14679, 14687, 14806, 14868, 14880
 14911, 14960, 15098, 15147, 15150, 15533, 15759, 15767, 15985, 15991, 16113, 16241, 16245, 16262, 16270, 16305
 16315, 16344, 16354, 16362, 16373, 16507, 16585, 17515, 17838, 17859, 17875, 18023, 18062, 18989, 19135, 19170
 19211, 19274, 19567, 19599, 19635, 20436, 20923, 21706, 21782, 21837, 21873, 21878, 22541, 22546, 22562, 22577
 22645, 22946, 23061, 23438, 24043, 24181, 24343, 24809, 24852, 25038, 25086, 25090, 25135, 25146, 25155, 25160
 25267, 25278, 25299, 25334, 25377, 25396, 25415, 25430, 25468, 25491, 25499, 25510, 25513, 25532, 25572, 25583
 25640, 25684, 25697, 25722, 25759, 25766, 26007, 26262, 26331, 26372, 27120, 27576, 27577, 27763, 27996, 28130
 28131, 28145, 28362, 28529, 28539, 28634, 28837, 29384, 29759, 29768, 29774, 29831, 29947, 30089, 30122, 30172
 30255, 30366, 30429, 30442, 30525, 30566, 30583, 30744, 30758, 30914, 30944, 31702, 32021, 32142, 32998, 33079
 35145, 35451, 35619, 36361, 37624, 37727, 38090, 38245, 39565, 39577, 39872, 40153, 40577, 40661, 40944, 41746
 42348, 44063, 44262, 44406, 44669, 44784, 45006, 45166, 45216, 45676, 45941, 46094, 46151, 46707, 46825, 47023
 47817, 48201, 48578, 50200, 52208, 52408, 52619, 52843, 54137, 54815, 54821, 56233, 56331, 56966, 58286, 58416
 58978, 59448, 59587, 60077, 62280, 65296, 65435, 67460, 69211, 72249, 72376, 72474, 74804, 76856, 77274, 77354
 77515,
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*Surface, type=ELEMENT, name=Surf-3
_Surf-3_S3, S3
_Surf-3_S4, S4
_Surf-3_S2, S2
_Surf-3_S1, S1
*End Assembly
**
** MATERIALS
**
*Material, name=Air
*Density
 1.3,
*Viscosity
 1.855e-05,
** ----------------------------------------------------------------
**
** STEP: Step-1
**
*Step, name=Step-1, nlgeom=NO
*CFD, incompressible navier stokes
0.01, 1., 0.025, 0.45, 1
1e-10, 0.5,  , 0.5, 0.5
*Momentum Equation Solver
50, 2, 1e-05
*Pressure Equation Solver
250, 2, 1e-05
ICC, 1, 1, CG
*Transport Equation Solver
50, 2, 1e-05
**
** BOUNDARY CONDITIONS
**
** Name: BC-1 Type: Fluid inlet/outlet
*Fluid Boundary, type=Surface
Surf-1, P, 100.
** Name: BC-2 Type: Fluid inlet/outlet
*Fluid Boundary, type=Surface
Surf-2, P, 10.
** Name: BC-3 Type: Fluid wall condition
*Fluid Boundary, type=Surface
Surf-3, VELX, 0.
Surf-3, VELY, 0.
Surf-3, VELZ, 0.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
*Output, history, frequency=0
*End Step
