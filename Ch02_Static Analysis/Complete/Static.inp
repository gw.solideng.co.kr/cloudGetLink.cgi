*Heading
** Job name: Static Model name: Static_Cantilever
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Cantilever
*Node
      1,        -12.5,         -15.,         100.
      2,        -12.5,       -11.25,         100.
      3,        -12.5,         -7.5,         100.
      4,        -12.5,        -3.75,         100.
      5,        -12.5,           0.,         100.
      6,        -12.5,         3.75,         100.
      7,        -12.5,          7.5,         100.
      8,        -12.5,        11.25,         100.
      9,        -12.5,          15.,         100.
     10,        -12.5,         -15.,          96.
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*Element, type=C3D8
   1,  235,  236,  245,  244,    1,    2,   11,   10
   2,  236,  237,  246,  245,    2,    3,   12,   11
   3,  237,  238,  247,  246,    3,    4,   13,   12
   4,  238,  239,  248,  247,    4,    5,   14,   13
   5,  239,  240,  249,  248,    5,    6,   15,   14
   6,  240,  241,  250,  249,    6,    7,   16,   15
   7,  241,  242,  251,  250,    7,    8,   17,   16
   8,  242,  243,  252,  251,    8,    9,   18,   17
   9,  244,  245,  254,  253,   10,   11,   20,   19
  10,  245,  246,  255,  254,   11,   12,   21,   20
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*Nset, nset=_PickedSet2, internal, generate
    1,  1638,     1
*Elset, elset=_PickedSet2, internal, generate
    1,  1200,     1
** Section: Solid_Steel
*Solid Section, elset=_PickedSet2, material=Steel
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Cantilever-1, part=Cantilever
*End Instance
**
*Node
      1,           0.,           0.,         100.
*Nset, nset=_PickedSet15, internal
 1,
*Nset, nset=_PickedSet16, internal
 1,
*Nset, nset=_PickedSet17, internal, instance=Cantilever-1
  226,  227,  228,  229,  230,  231,  232,  233,  234,  460,  461,  462,  463,  464,  465,  466
  467,  468,  694,  695,  696,  697,  698,  699,  700,  701,  702,  928,  929,  930,  931,  932
  933,  934,  935,  936, 1162, 1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1396, 1397, 1398
 1399, 1400, 1401, 1402, 1403, 1404, 1630, 1631, 1632, 1633, 1634, 1635, 1636, 1637, 1638
*Elset, elset=_PickedSet17, internal, instance=Cantilever-1
  193,  194,  195,  196,  197,  198,  199,  200,  393,  394,  395,  396,  397,  398,  399,  400
  593,  594,  595,  596,  597,  598,  599,  600,  793,  794,  795,  796,  797,  798,  799,  800
  993,  994,  995,  996,  997,  998,  999, 1000, 1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200
*Elset, elset=__PickedSurf14_S3, internal, instance=Cantilever-1
    1,    2,    3,    4,    5,    6,    7,    8,  201,  202,  203,  204,  205,  206,  207,  208
  401,  402,  403,  404,  405,  406,  407,  408,  601,  602,  603,  604,  605,  606,  607,  608
  801,  802,  803,  804,  805,  806,  807,  808, 1001, 1002, 1003, 1004, 1005, 1006, 1007, 1008
*Surface, type=ELEMENT, name=_PickedSurf14, internal
__PickedSurf14_S3, S3
** Constraint: Coupling
*Coupling, constraint name=Coupling, ref node=_PickedSet15, surface=_PickedSurf14
*Kinematic
*End Assembly
**
** MATERIALS
**
*Material, name=Steel
*Elastic
 2.141e+06, 0.3
** ----------------------------------------------------------------
**
** STEP: Static
**
*Step, name=Static, nlgeom=NO
*Static
0.1, 1., 1e-05, 1.
**
** BOUNDARY CONDITIONS
**
** Name: Fix Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet17, PINNED
**
** LOADS
**
** Name: Force   Type: Concentrated force
*Cload
_PickedSet16, 2, -150.
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
