*Heading
** Job name: CEL_meshmotion Model name: meshmotion
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Euler
*Node
      1,           0.,           0.,           1.
      2,           0.,         12.5,           1.
      3,         -40.,         12.5,           1.
      4,         -40.,           0.,           1.
      5,           0.,         12.5,           0.
      6,         -40.,         12.5,           0.
      7,         -40.,           0.,           0.
      8,           0.,           0.,           0.
      9,          40.,         12.5,           0.
     10,          40.,         12.5,           1.
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*Element, type=EC3D8R
  1,    8,  130, 1075,  182,    1,   17,  607,  118
  2,  130,  129, 1076, 1075,   17,   18,  608,  607
  3,  129,  128, 1077, 1076,   18,   19,  609,  608
  4,  128,  127, 1078, 1077,   19,   20,  610,  609
  5,  127,  126, 1079, 1078,   20,   21,  611,  610
  6,  126,  125, 1080, 1079,   21,   22,  612,  611
  7,  125,  124, 1081, 1080,   22,   23,  613,  612
  8,  124,  123, 1082, 1081,   23,   24,  614,  613
  9,  123,  122, 1083, 1082,   24,   25,  615,  614
 10,  122,  121, 1084, 1083,   25,   26,  616,  615
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*Nset, nset=Set-1, generate
    1,  4374,     1
*Elset, elset=Set-1, generate
    1,  2080,     1
** Section: Euler
*Eulerian Section, elset=Set-1
Water, water-1
*Surface, type=EULERIAN MATERIAL, name=water-1
water-1
*End Part
**
*Part, name=Plate
*Node
      1,           5.,          25.,           1.
      2,           5.,   24.0277786,           1.
      3,           5.,   23.0555553,           1.
      4,           5.,    22.083334,           1.
      5,           5.,   21.1111107,           1.
      6,           5.,   20.1388893,           1.
      7,           5.,    19.166666,           1.
      8,           5.,   18.1944447,           1.
      9,           5.,   17.2222214,           1.
     10,           5.,        16.25,           1.
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*Element, type=C3D8R
 1,  39,  40,  59,  58,   1,   2,  21,  20
 2,  40,  41,  60,  59,   2,   3,  22,  21
 3,  41,  42,  61,  60,   3,   4,  23,  22
 4,  42,  43,  62,  61,   4,   5,  24,  23
 5,  43,  44,  63,  62,   5,   6,  25,  24
 6,  44,  45,  64,  63,   6,   7,  26,  25
 7,  45,  46,  65,  64,   7,   8,  27,  26
 8,  46,  47,  66,  65,   8,   9,  28,  27
 9,  47,  48,  67,  66,   9,  10,  29,  28
10,  48,  49,  68,  67,  10,  11,  30,  29
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*Nset, nset=_PickedSet2, internal, generate
   1,  228,    1
*Elset, elset=_PickedSet2, internal, generate
  1,  90,   1
** Section: Plate
*Solid Section, elset=_PickedSet2, material=Steel
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Euler-1, part=Euler
*End Instance
**
*Instance, name=Plate-1, part=Plate
*End Instance
**
*Nset, nset=Water, instance=Euler-1
    1,    2,    3,    4,    5,    6,    7,    8,   17,   18,   19,   20,   21,   22,   23,   24
   25,   26,   27,   28,   29,   30,   31,   32,   33,   34,   35,   36,   37,   38,   39,   40
   41,   42,   43,   44,   45,   46,   47,   48,   49,   50,   51,   52,   53,   54,   55,   56
   57,   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,   68,   69,   70,   71,   72
   73,   74,   75,   76,   77,   78,   79,   80,   81,   82,   83,   84,   85,   86,   87,   88
   89,   90,   91,   92,   93,   94,   95,   96,   97,   98,   99,  100,  101,  102,  103,  104
  105,  106,  107,  108,  109,  110,  111,  112,  113,  114,  115,  116,  117,  118,  119,  120
  121,  122,  123,  124,  125,  126,  127,  128,  129,  130,  131,  132,  133,  134,  135,  136
  137,  138,  139,  140,  141,  142,  143,  144,  145,  146,  147,  148,  149,  150,  151,  152
  153,  154,  155,  156,  157,  158,  159,  160,  161,  162,  163,  164,  165,  166,  167,  168
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*Elset, elset=Water, instance=Euler-1, generate
   1,  520,    1
*Nset, nset=_PickedSet7, internal, instance=Euler-1
   3,   4,   6,   7,  68,  69,  70,  71,  72,  73,  74,  75,  76,  77,  78,  79
 170, 171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 181
*Elset, elset=_PickedSet7, internal, instance=Euler-1, generate
 508,  520,    1
*Nset, nset=_PickedSet8, internal, instance=Euler-1
   1,   4,   7,   8,  11,  12,  80,  81,  82,  83,  84,  85,  86,  87,  88,  89
  90,  91,  92,  93,  94,  95,  96,  97,  98,  99, 100, 101, 102, 103, 104, 105
 106, 107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 117, 118, 182, 183, 184
 185, 186, 187, 188, 189, 190, 191, 192, 193, 194, 195, 196, 197, 198, 199, 200
 201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 215, 216
 217, 218, 219, 220, 245, 246, 247, 248, 249, 250, 251, 252, 253, 254, 255, 256
 257, 258, 259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 271, 272
 273, 274, 275, 276, 277, 278, 279, 280, 281, 282, 283, 323, 324, 325, 326, 327
 328, 329, 330, 331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 341, 342, 343
 344, 345, 346, 347, 348, 349, 350, 351, 352, 353, 354, 355, 356, 357, 358, 359
 360, 361
*Elset, elset=_PickedSet8, internal, instance=Euler-1
    1,   14,   27,   40,   53,   66,   79,   92,  105,  118,  131,  144,  157,  170,  183,  196
  209,  222,  235,  248,  261,  274,  287,  300,  313,  326,  339,  352,  365,  378,  391,  404
  417,  430,  443,  456,  469,  482,  495,  508,  533,  546,  559,  572,  585,  598,  611,  624
  637,  650,  663,  676,  689,  702,  715,  728,  741,  754,  767,  780,  793,  806,  819,  832
  845,  858,  871,  884,  897,  910,  923,  936,  949,  962,  975,  988, 1001, 1014, 1027, 1040
*Nset, nset=_PickedSet9, internal, instance=Euler-1
   9,  10,  11,  12,  13,  14, 221, 222, 223, 224, 225, 226, 227, 228, 229, 230
 231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 241, 242, 243, 244, 401, 402
 403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 417, 418
 419, 420, 421, 422, 423, 424
*Elset, elset=_PickedSet9, internal, instance=Euler-1
  521,  522,  523,  524,  525,  526,  527,  528,  529,  530,  531,  532,  533, 1041, 1042, 1043
 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 1053
*Nset, nset=_PickedSet10, internal, instance=Euler-1, generate
    1,  4374,     1
*Nset, nset=_PickedSet10, internal, instance=Plate-1, generate
   1,  228,    1
*Elset, elset=_PickedSet10, internal, instance=Euler-1, generate
    1,  2080,     1
*Elset, elset=_PickedSet10, internal, instance=Plate-1, generate
  1,  90,   1
*Nset, nset=_PickedSet11, internal, instance=Plate-1, generate
   1,  210,   19
*Elset, elset=_PickedSet11, internal, instance=Plate-1, generate
  1,  73,  18
*End Assembly
**
** MATERIALS
**
*Material, name=Steel
*Density
7800.,
*Elastic
 2e+11, 0.3
*Material, name=Water
*Density
998.,
*Eos, type=USUP
1500.,0.,0.
*Viscosity
 1.26765e-05,
**
** INTERACTION PROPERTIES
**
*Surface Interaction, name=nofric
*Friction
0.,
**
** PREDEFINED FIELDS
**
** Name: volfrac   Type: Material assignment
*Initial Conditions, type=VOLUME FRACTION
Water, Euler-1.water-1, 1.
** ----------------------------------------------------------------
**
** STEP: Explicit
**
*Step, name=Explicit, nlgeom=YES
*Dynamic, Explicit
, 10.
*Bulk Viscosity
0.06, 1.2
**
** BOUNDARY CONDITIONS
**
** Name: Vel_Inflow Type: Velocity/Angular velocity
*Boundary, type=VELOCITY
_PickedSet7, 1, 1, 2.
** Name: meshmotion Type: Eulerian mesh motion
*Eulerian Mesh Motion, elset=Euler-1.Set-1, surface=Euler-1.water-1
 ,  ,  ,  ,  ,
 FIXED,  FIXED,  FIXED,  ,  FIXED,  FIXED
 FIXED,  ,  FIXED
** Name: plate_fix Type: Velocity/Angular velocity
*Boundary, type=VELOCITY
_PickedSet11, 1, 1
_PickedSet11, 2, 2
** Name: x-fix Type: Velocity/Angular velocity
*Boundary, type=VELOCITY
_PickedSet9, 1, 1
** Name: y-fix Type: Velocity/Angular velocity
*Boundary, type=VELOCITY
_PickedSet8, 2, 2
** Name: z-fix Type: Velocity/Angular velocity
*Boundary, type=VELOCITY
_PickedSet10, 3, 3
**
** LOADS
**
** Name: Gravity   Type: Gravity
*Dload
, GRAV, 9.81, 0., -1., 0.
**
** INTERACTIONS
**
** Interaction: General
*Contact, op=NEW
*Contact Inclusions, ALL EXTERIOR
*Contact Property Assignment
 ,  , nofric
**
** OUTPUT REQUESTS
**
*Restart, write, number interval=1, time marks=NO
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, variable=PRESELECT
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
