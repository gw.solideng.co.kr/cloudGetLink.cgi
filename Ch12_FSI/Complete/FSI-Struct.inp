*Heading
** Job name: FSI-Struct Model name: Struct
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=Struct
*Node
      1,           5.,          25.,           2.
      2,           5.,         24.5,           2.
      3,           5.,          24.,           2.
      4,           5.,         23.5,           2.
      5,           5.,          23.,           2.
      6,           5.,         22.5,           2.
      7,           5.,          22.,           2.
      8,           5.,         21.5,           2.
      9,           5.,          21.,           2.
     10,           5.,         20.5,           2.
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*Element, type=C3D8R
  1,  103,  104,  155,  154,    1,    2,   53,   52
  2,  104,  105,  156,  155,    2,    3,   54,   53
  3,  105,  106,  157,  156,    3,    4,   55,   54
  4,  106,  107,  158,  157,    4,    5,   56,   55
  5,  107,  108,  159,  158,    5,    6,   57,   56
  6,  108,  109,  160,  159,    6,    7,   58,   57
  7,  109,  110,  161,  160,    7,    8,   59,   58
  8,  110,  111,  162,  161,    8,    9,   60,   59
  9,  111,  112,  163,  162,    9,   10,   61,   60
 10,  112,  113,  164,  163,   10,   11,   62,   61
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*Nset, nset=_PickedSet5, internal, generate
    1,  1122,     1
*Elset, elset=_PickedSet5, internal, generate
   1,  500,    1
** Section: Struct
*Solid Section, elset=_PickedSet5, material=Aluminum
,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=Struct-1, part=Struct
*End Instance
**
*Nset, nset=_PickedSet5, internal, instance=Struct-1, generate
    1,  1122,     1
*Elset, elset=_PickedSet5, internal, instance=Struct-1, generate
   1,  500,    1
*Nset, nset=_PickedSet6, internal, instance=Struct-1, generate
   51,  1122,    51
*Elset, elset=_PickedSet6, internal, instance=Struct-1, generate
  50,  500,   50
*Elset, elset=__PickedSurf4_S1, internal, instance=Struct-1, generate
 451,  500,    1
*Elset, elset=__PickedSurf4_S6, internal, instance=Struct-1, generate
   1,  451,   50
*Elset, elset=__PickedSurf4_S2, internal, instance=Struct-1, generate
  1,  50,   1
*Surface, type=ELEMENT, name=_PickedSurf4, internal
__PickedSurf4_S1, S1
__PickedSurf4_S6, S6
__PickedSurf4_S2, S2
*End Assembly
**
** MATERIALS
**
*Material, name=Aluminum
*Density
2700.,
*Elastic
 7.3e+10, 0.35
** ----------------------------------------------------------------
**
** STEP: Struct
**
*Step, name=Struct, nlgeom=NO, inc=1000000
*Dynamic
0.0001,2.,1e-07,0.1
**
** BOUNDARY CONDITIONS
**
** Name: Fix Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet6, PINNED
** Name: ZSYMM Type: Symmetry/Antisymmetry/Encastre
*Boundary
_PickedSet5, ZSYMM
** Interaction: FSI_Boundary
*Co-simulation, name=FSI_Boundary, program=MULTIPHYSICS
*Co-simulation Region, import, type=SURFACE
_PickedSurf4, CF
_PickedSurf4, LUMPEDMASS
*Co-simulation Region, export, type=SURFACE
_PickedSurf4, U
_PickedSurf4, V
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, time interval=0.1
*Node Output
A, U, V
*Element Output, directions=YES
S,
**
** HISTORY OUTPUT: H-Output-1
**
*Output, history, variable=PRESELECT
*End Step
