*Heading
** Job name: FSI-CFD Model name: CFD
** Generated by: Abaqus/CAE 6.13-1
*Preprint, echo=NO, model=NO, history=NO, contact=NO
**
** PARTS
**
*Part, name=CFD
*Node
      1,           0.,          22.,           0.
      2,           0.,          19.,           0.
      3,           0.,         15.5,           0.
      4,           0.,         12.5,           0.
      5,           0.,          9.5,           0.
      6,           0.,          6.5,           0.
      7,           0.,           3.,           0.
      8,           0.,          25.,           0.
      9,           0.,           0.,           0.
     10,  -3.84615374,           0.,           0.
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*Element, type=FC3D8
   1, 2759,  842,  685,  684, 5996, 4079, 3922, 3921
   2,  783,  844,  688,  687, 4020, 4081, 3925, 3924
   3, 1130, 1227, 1233,  186, 4367, 4464, 4470, 3423
   4, 1228, 2808, 1234, 1089, 4465, 6045, 4471, 4326
   5, 1137, 1092, 1091, 1172, 4374, 4329, 4328, 4409
   6,  162, 1180, 1094, 1117, 3399, 4417, 4331, 4354
   7, 1182, 1194, 1126, 1114, 4419, 4431, 4363, 4351
   8, 1113, 1413, 1187, 1110, 4350, 4650, 4424, 4347
   9, 1183, 1184, 1123, 1105, 4420, 4421, 4360, 4342
  10, 1122, 1189, 1181, 1102, 4359, 4426, 4418, 4339
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*Nset, nset=_PickedSet2, internal, generate
    1,  6474,     1
*Elset, elset=_PickedSet2, internal, generate
    1,  3107,     1
** Section: Fluid
*Fluid Section, type=SINGLE FLUID, elset=_PickedSet2
Fluid,
*End Part
**
**
** ASSEMBLY
**
*Assembly, name=Assembly
**
*Instance, name=CFD-1, part=CFD
*End Instance
**
*Nset, nset=_PickedSet9, internal, instance=CFD-1
    9,   10,   11,   12,   13,   14,   15,   16,   17,   18,   19,   20,   21,   22,   23,   24
   25,   26,   27,   28,   29,   30,   31,   32,   33,   34,   35,   36,   37,   38,   39,   40
   41,   42,   43,   44,   45,   46,   47,   48,   49,   50,   51,   52,   53,   54,   55,   56
   57,   58,   59,   60,   61,   62,   63,   64,   65,   66,   67,   68,   69,   70,   71,   72
   73,   74,   75,   76,   77,   78,   79,   80,   81,   82,   83,   84,   85,   86,   87,   88
   89,   90,   91,   92,   93,   94,   95,   96,   97,   98,   99,  100,  101,  102,  103,  104
  105,  106,  107,  108,  109,  110,  111,  112,  113,  689,  690,  691,  692,  693,  694,  695
  696,  697,  698,  699,  700,  701,  702,  703,  704,  705,  706,  707,  708,  709,  710,  711
  712,  713,  714,  715,  716,  717,  718,  719,  720,  721,  722,  723,  724,  725,  726,  727
  728,  729,  730,  731,  732, 3246, 3247, 3248, 3249, 3250, 3251, 3252, 3253, 3254, 3255, 3256
 3257, 3258, 3259, 3260, 3261, 3262, 3263, 3264, 3265, 3266, 3267, 3268, 3269, 3270, 3271, 3272
 3273, 3274, 3275, 3276, 3277, 3278, 3279, 3280, 3281, 3282, 3283, 3284, 3285, 3286, 3287, 3288
 3289, 3290, 3291, 3292, 3293, 3294, 3295, 3296, 3297, 3298, 3299, 3300, 3301, 3302, 3303, 3304
 3305, 3306, 3307, 3308, 3309, 3310, 3311, 3312, 3313, 3314, 3315, 3316, 3317, 3318, 3319, 3320
 3321, 3322, 3323, 3324, 3325, 3326, 3327, 3328, 3329, 3330, 3331, 3332, 3333, 3334, 3335, 3336
 3337, 3338, 3339, 3340, 3341, 3342, 3343, 3344, 3345, 3346, 3347, 3348, 3349, 3350, 3926, 3927
 3928, 3929, 3930, 3931, 3932, 3933, 3934, 3935, 3936, 3937, 3938, 3939, 3940, 3941, 3942, 3943
 3944, 3945, 3946, 3947, 3948, 3949, 3950, 3951, 3952, 3953, 3954, 3955, 3956, 3957, 3958, 3959
 3960, 3961, 3962, 3963, 3964, 3965, 3966, 3967, 3968, 3969
*Elset, elset=_PickedSet9, internal, instance=CFD-1
   20,   21,   70,   71,   88,   89,  105,  106,  122,  123,  124,  139,  140,  141,  159,  160
  161,  163,  165,  168,  172,  177,  178,  179,  189,  219,  220,  221,  223,  229,  230,  231
  237,  238,  248,  258,  269,  279,  289,  290,  299,  308,  309,  319,  328,  338,  348,  359
  367,  378,  389,  390,  398,  408,  409,  419,  427,  428,  436,  451,  461,  462,  464,  467
  469,  474,  475,  476,  480,  482,  485,  486,  488,  490,  492,  493,  494,  496,  497,  498
  508,  516,  526,  527,  537,  545,  546,  556,  564,  565,  575,  584,  593,  601,  621,  629
  630,  639,  656,  657,  675,  682,  694,  702,  703,  712,  766,  767,  796,  818,  838,  879
 1066, 1068, 1069, 1070, 1071, 1072, 1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082
 1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1334, 1795, 2377, 2405, 2408, 2410, 2411, 2417
*Elset, elset=__PickedSurf4_S6, internal, instance=CFD-1
  198,  646,  648,  931,  971, 1017, 1034, 1066, 1092, 1094, 1095, 1097, 1098, 1099, 1101, 1102
 1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1113, 1114, 1119, 1120, 1122, 1123, 1124
 1126, 1127, 1129
*Elset, elset=__PickedSurf4_S5, internal, instance=CFD-1
    1,    2,   33,   34,   35,   37,   38,   40,   43,   46,   47,   50,   52,   53,  639, 1132
 1141, 1143
*Elset, elset=__PickedSurf4_S4, internal, instance=CFD-1
  187,  188,  640,  641,  642,  643,  644,  645,  951, 1116, 1117, 1125, 1128, 1151, 1193, 1197
 1201, 1206, 1210, 1212, 1215, 1218, 1226, 1229, 1231
*Elset, elset=__PickedSurf4_S3, internal, instance=CFD-1
   49, 1036, 1037, 1038, 1040, 1041, 1042, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052
 1053, 1055, 1056, 1060, 1062, 1063, 1065, 1158, 1163, 1167, 1172, 1177, 1180, 1183, 1186, 1189
*Surface, type=ELEMENT, name=_PickedSurf4, internal
__PickedSurf4_S6, S6
__PickedSurf4_S5, S5
__PickedSurf4_S4, S4
__PickedSurf4_S3, S3
*Elset, elset=__PickedSurf5_S6, internal, instance=CFD-1
  163,  165,  168,  172,  177,  657,  675,  702,  712,  796, 1070, 1071, 1073, 1074, 1075
*Elset, elset=__PickedSurf5_S4, internal, instance=CFD-1
  656,  682,  694,  703,  767,  818, 1072, 1077
*Elset, elset=__PickedSurf5_S5, internal, instance=CFD-1
 838,
*Elset, elset=__PickedSurf5_S3, internal, instance=CFD-1
 1076,
*Surface, type=ELEMENT, name=_PickedSurf5, internal
__PickedSurf5_S6, S6
__PickedSurf5_S4, S4
__PickedSurf5_S5, S5
__PickedSurf5_S3, S3
*Elset, elset=__PickedSurf6_S4, internal, instance=CFD-1
 219, 220, 221, 469, 476
*Elset, elset=__PickedSurf6_S5, internal, instance=CFD-1
  223,  488,  492,  496,  879, 1083, 2410, 2411
*Elset, elset=__PickedSurf6_S6, internal, instance=CFD-1
  461,  467,  475,  482,  766, 1082, 1084, 1085, 1086, 1087
*Elset, elset=__PickedSurf6_S3, internal, instance=CFD-1
 462, 464
*Surface, type=ELEMENT, name=_PickedSurf6, internal
__PickedSurf6_S4, S4
__PickedSurf6_S5, S5
__PickedSurf6_S6, S6
__PickedSurf6_S3, S3
*Elset, elset=__PickedSurf7_S2, internal, instance=CFD-1, generate
    1,  3107,     1
*Elset, elset=__PickedSurf7_S1, internal, instance=CFD-1, generate
    1,  3107,     1
*Surface, type=ELEMENT, name=_PickedSurf7, internal
__PickedSurf7_S2, S2
__PickedSurf7_S1, S1
*Elset, elset=__PickedSurf8_S4, internal, instance=CFD-1
   89,  106,  123,  124,  141,  161,  230,  319,  390,  409,  428,  474,  486,  490,  493,  494
  496,  498,  508,  527,  546,  565,  575,  601,  621, 1088, 1089, 1090, 1334, 2377
*Elset, elset=__PickedSurf8_S5, internal, instance=CFD-1
   20,   70,   71,   88,  105,  122,  139,  159,  160,  177,  189,  248,  258,  279,  299,  436
  629, 1066, 1078, 1081, 2405
*Elset, elset=__PickedSurf8_S6, internal, instance=CFD-1
  178,  229,  231,  237,  289,  308,  328,  338,  348,  359,  378,  389,  398,  408,  419,  427
  480,  485,  497,  516,  526,  537,  545,  556,  564,  584,  593,  639, 1068, 1069, 1079, 1795
 2408,
*Elset, elset=__PickedSurf8_S3, internal, instance=CFD-1
   21,  140,  179,  238,  269,  290,  309,  367,  451,  461,  630, 1070, 1080, 2417
*Surface, type=ELEMENT, name=_PickedSurf8, internal
__PickedSurf8_S4, S4
__PickedSurf8_S5, S5
__PickedSurf8_S6, S6
__PickedSurf8_S3, S3
*End Assembly
**
** MATERIALS
**
*Material, name=Fluid
*Density
1000.,
*Viscosity
 0.1,
** ----------------------------------------------------------------
**
** STEP: CFD
**
*Step, name=CFD, nlgeom=NO
*CFD, incompressible navier stokes
0.01, 2., 0.1, 0.45, 1
1e-10, 0.5,  , 0.5, 0.5
*Momentum Equation Solver
50, 2, 1e-05
*Pressure Equation Solver
250, 2, 1e-05
ICC, 1, 1, CG
*Transport Equation Solver
50, 2, 1e-05
**
** BOUNDARY CONDITIONS
**
** Name: Fix Type: Displacement/Rotation
*Boundary
_PickedSet9, 1, 1
_PickedSet9, 2, 2
_PickedSet9, 3, 3
** Name: Inlet Type: Fluid inlet/outlet
*Fluid Boundary, type=Surface
_PickedSurf5, VELX, 50.
** Name: Outlet Type: Fluid inlet/outlet
*Fluid Boundary, type=Surface
_PickedSurf6, P, 0.
** Name: SYMM Type: Fluid inlet/outlet
*Fluid Boundary, type=Surface
_PickedSurf7, VELZ, 0.
** Name: Wall Type: Fluid wall condition
*Fluid Boundary, type=Surface
_PickedSurf8, VELX, 0.
_PickedSurf8, VELY, 0.
_PickedSurf8, VELZ, 0.
** Interaction: FSI_Boundary
*Co-simulation, name=FSI_Boundary, program=MULTIPHYSICS
*Co-simulation Region, import, type=SURFACE
_PickedSurf4, U
_PickedSurf4, V
*Co-simulation Region, export, type=SURFACE
_PickedSurf4, LUMPEDMASS
_PickedSurf4, TRSHR
**
** OUTPUT REQUESTS
**
*Restart, write, frequency=0
**
** FIELD OUTPUT: F-Output-1
**
*Output, field, time interval=0.1
*Node Output
PRESSURE, U, V
*Output, history, frequency=0
*End Step
